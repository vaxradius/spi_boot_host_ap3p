# Keil uVision project uart_boot_host.uvprojx, settings and files
target uart_boot_host (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_boot_host
  AfterMake: fromelf --bin --output bin\uart_boot_host.bin bin\uart_boot_host.axf
  AfterMake: fromelf -cedrst --output bin\uart_boot_host.txt bin\uart_boot_host.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3P keil
  c include: ../../../../../utils;../../../../../CMSIS/ARM/Include;../../../bsp;../src;../../../../../mcu/apollo3p;../../../../..;../../../../../devices;../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\uart_boot_host.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: uart_boot_host.c img_data.s
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo3p/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
